# IAR project STM8S_Slave.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\StdPeriph\inc; ..\User\App; ..\User\Driver; ..\User\HAL; ..\User\Middle
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_Slave.srec
  ILINK.IlinkOutputFile: STM8S_Slave.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph
    ../StdPeriph/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User
    ../User/: main.c
  group User/App
    ../User/App/: task.c
  group User/Driver
    ../User/Driver/: button.c device.c ds18b20.c led.c ticker.c
  group User/HAL
    ../User/HAL/: eeprom.c gpio.c i2c.c timer.c uart.c
  group User/Middle
    ../User/Middle/: protocol.c reg.c
